TTYS="tty1 ttyLP0"
